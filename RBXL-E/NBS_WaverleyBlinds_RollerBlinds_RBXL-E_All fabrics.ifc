Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2017-12-08T10:06:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 08 10:06:10 2017 * Host: yourcadben * Database: C:\Users\YOURCA~1\AppData\Local\Temp\{8E79C582-5D4D-4D92-8172-787F1447EE5D}\ifc * Database version: 5507 * Database creation date: Fri Dec 08 10:06:10 2017 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 08 10:06:10 2017 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 08 10:06:10 2017 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: Z:\Waverley\Content\RBXL-E\NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics, NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics:NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics:5446
In: Level 1
Material: NBS_Concept
Pset_BuildingElementProxyCommon - Reference: n/a
Pset_ManufacturerTypeInformation - ModelReference: RBXL-E; Manufacturer: sales@waverleyblinds.com
Constraints - CeilingFixingCalc: yes; FabricDropCalc: 1500 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm; RollerBlindSystemDropCalc: 2000 mm; RollerBlindSystemWidthCalc: 2000 mm; MaximumSystemDrop: 8000 mm; MaximumSystemWidth: 4000 mm
Construction - CeilingFixed: no; Fascia: no; RecessFixed: no; SquareCassette: no; WallFixed: yes
Dimensions - Area: 4.41327 m2; HorizontalOffset: 55 mm; MountingHeight: 500 mm; RollerBlindFabricDrop: 1500 mm; RollerBlindSystemDrop: 2000 mm; RollerBlindSystemWidth: 2000 mm; VerticalOffset: 55 mm; Volume: 0.0139841 m3; FabricDropPlacement: 85 mm; FabricRollRadius: 42.5 mm; LightGapLeft: 19 mm; LightGapRight: 27 mm
Other - AssetIdentifier: n/a; BarCode: n/a; Category: Generic Models; Family: NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics: NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics; Family and Type: NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics: NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics; InstallationDate: 1900-12-31T23:59:59; NominalHeight: 2000 mm; NominalWidth: 2000 mm; SerialNumber: n/a; TagNumber: n/a; Type: NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics: NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics; Type Id: NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics: NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics; WarrantyStartDate: 1900-12-31T23:59:59; AccessibilityPerformance: n/a; AssetType: Fixed; CodePerformance: n/a; Color: http://www.waverleyblinds.com/architects/wp-content/uploads/2015/03/Alphashade-FULL.compressed.pdf; http://www.waverleyblinds.com/architects/wp-content/uploads/2015/03/Betascreen-Full.compressed.pdf; http://www.waverleyblinds.com/architects/wp-content/uploads/2015/03/Deltablock-Full.compressed.pdf; http://www.waverleyblinds.com/architects/wp-content/uploads/2015/03/Sigmatex-Omega-Full.compressed.pdf; http://www.waverleyblinds.com/architects/wp-content/uploads/2015/03/Thetablock-Full.compressed.pdf; http://www.waverleyblinds.com/architects/wp-content/uploads/2015/03/SmartShade-%C2%AB-EDITED.compressed.pdf; http://www.waverleyblinds.com/architects/wp-content/uploads/2015/03/Verosol-%C2%AB-EDITED.compressed-1.pdf; Constituents: n/a; DurationUnit: year; ExpectedLife: 15 years; Family Name: NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics; Features: n/a; Finish: n/a; Grade: n/a; Material: n/a; ModelNumber: n/a; ModelReference: RBXL-E; Name: RollerBlinds_RBXL-E_Alphashade_WaverleyBlinds; NominalLength: 0 mm; ReplacementCost: n/a; Shape: n/a; Size: Maximum: 10000 x 4000 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Phasing - Phase Created: New Construction
Visibility - CeilingMountRoundCassette: no
Data - Accessories: 120mm fascia; 120mm cassette; 115mm ceiling pocket; hem bars in silver anodized or powder coated aluminium; in-line, angled or combination link brackets; BlindBlackoutFunction: Anti-glare & anti-heat; BlindFinish: n/a; BlindMaterial: n/a; BlindPattern: n/a; BottomBarOptions: Round, teardrop, rectangular or fabric enclosed; ColourFastness: 7/8; EndCoverOptions: White, grey or black end covers; EnvironmentalProductDeclaration: n/a; FabricOptions: Any fabric from AlphaShade, BetaScreen, Deltablock, SigmaTex, ThetaBlock, SmartShade or Verosol ranges; FabricThickness: 0 mm; FabricWeight: 290g/m²; FixingOptions: Ceiling, wall or recess fixed.; Flammability: BS 7837, BS 5867, M1, B1 and B-s,d0; Gvalue: 0; MaximumHeight: 8000 mm; MaximumWeight: 103kg; MaximumWidth: 4000 mm; MechanismEndurance: n/a; OpennessFactor: 3%; OperatingEffort: n/a; Operation: 240V tubular motor with five year guarantee – standard (hard wired) or RTS (radio remote switching); Position: Internal - separate to glazing; SafetyCordRetainer: n/a; ShadingFactor: 0; SolarAbsorption: 0; SupportBracket: n/a; SupportBracketHookInPlate: n/a; SupportBracketSideCover: n/a; SupportBracketTopCover: n/a; SystemDropOptions: Up to 8000mm; Testing: n/a; Tube: n/a; TubeCoversColour: n/a; TubeCoversMaterial: Aluminium; TubeDiameter: 60 or 80mm; TubeMaterial: Aluminium; UVTransmission: n/a; VisibleLightAbsorption: n/a
General - Author: NBS; BIMObjectName: NBS_WaverleyBlinds_RollerBlinds_RBXL-E_Alphashade; ManufacturerName: Waverley Blinds; ManufacturerURL: www.waverleyblinds.com; NBSCertification: www.nationalbimlibrary.com/cert/jw0hrfdi; NBSDescription: Heavy duty electrically operated roller blinds for large glazed areas; NBSNote: n/a; NBSOfficeMasterTag: n/a; NBSReference: 45-25-10/360; NBSTypeID: n/a; ProductInformation: http://www.waverleyblinds.com/architects/wp-content/uploads/2014/09/Roller-blinds.pdf; Revision: n/a; Uniclass2015Code: Pr_30_59_07_72; Uniclass2015Title: Roller blinds; Uniclass2015Version: Products v1.4; Version: 2
Identity Data - Description: Heavy duty motorized roller blind system; Manufacturer: sales@waverleyblinds.com; Type Name: NBS_WaverleyBlinds_RollerBlinds_RBXL-E_All fabrics
Materials and Finishes - BottomBarMaterial: NBS_Concept; CassetteMaterial: NBS_Concept; FasciaMaterial: NBS_Concept; FixingMaterial: NBS_Concept; RollerBlindFabricMaterial: NBS_Concept
